# Keil uVision project Vehicle_BMS_Master.uvprojx, settings and files
target Vehicle_BMS_Master (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Vehicle_BMS_Master +hex
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F767xx,USE_HAL_DRIVER
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\SDRAM;..\HARDWARE\24CXX;..\HARDWARE\SDMMC;..\HARDWARE\NAND;..\HARDWARE\MPU;..\USMART;..\MALLOC;..\BMS;..\HARDWARE\BSP_GPIO;..\HARDWARE\BSP_UART;..\HARDWARE\BSP_IWDG;..\HARDWARE\BSP_RTC;..\HARDWARE\BSP_SPI;..\HARDWARE\BSP_ADC;..\HARDWARE\BSP_LTC6804;..\HARDWARE\BSP_EEPROM;..\HARDWARE\BSP_TIMER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_it.c system_stm32f7xx.c includes.h Globals.c Config.h NTC10K3950.c BMS_HMI_Com.c SOC_Calculate.c RingBuffer.c Fault_Diagnose_Protect.c Signal_Collect_Process.c Memory.c stm32f767xx.h
  group CORE
    ../CORE/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sram.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_nand.c stm32f7xx_hal_can.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/BSP_GPIO/: BSP_GPIO.c
    ../HARDWARE/BSP_UART/: BSP_UART.c
    ../HARDWARE/BSP_IWDG/: BSP_IWDG.c
    ../HARDWARE/BSP_ADC/: BSP_ADC.c
    ../HARDWARE/BSP_LTC6804/: BSP_LTC6804.c
    ../HARDWARE/BSP_EEPROM/: BSP_EEPROM.c
    ../HARDWARE/BSP_TIMER/: BSP_TIMER.c
  group MALLOC
    ../MALLOC/: malloc.c
